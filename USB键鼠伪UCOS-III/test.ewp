# IAR project test.ewp, settings and files
configuration stm32f407 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER; __FPU_PRESENT; __FPU_USED; ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __ICCARM__; OS_SUPPORT; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: cmsic; drive; library\inc; startup; user; jpg; dsp_lib\Include; UCOS-III\uC-CPU\ARM-Cortex-M4\IAR; UCOS-III\uC-CPU; UCOS-III\uC-LIB; UCOS-III\uC-LIB\Ports\ARM-Cortex-M4\IAR; UCOS-III\uCOS_CONFIG; UCOS-III\uCOS-III\Source; UCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; UCOS-III\UCOS_BSP; EMWIN\STemWin\inc; EMWIN\STemWin\Config; EMWIN\Demo; LWIP\lwip-1.4.1\src\include; LWIP\lwip-1.4.1\src\include\ipv4; LWIP\lwip-1.4.1\src\include\netif; LWIP\arch; LWIP; LWIP\lwip_app\lwip_comm; LWIP\lwip_app\udp_demo; EMWIN\XBF_FONT; FATFS; USB\USB_APP; USB\STM32_USB_OTG_Driver\inc; USB\STM32_USB_Device_Library\Class\msc\inc; USB\STM32_USB_Device_Library\Core\inc; USB\STM32_USB_HOST_Library\Core\inc; USB\STM32_USB_HOST_Library\Class\HID\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: test.srec
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkIcfFile: test.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cmsic
    cmsic/: system_stm32f4xx.c
  group dsp_lib
    dsp_lib/: arm_cortexM4lf_math.lib
  group EMWIN/Demo
    EMWIN/Demo/: demo.c graphy.c
  group EMWIN/STemWin/Config
    EMWIN/STemWin/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIConf.h GUIDRV_Template.c GUIDRV_Template.h LCDConf_FlexColor_Template.c
  group EMWIN/STemWin/inc
    EMWIN/STemWin/inc/: BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_SIM_Win32.h GUI_SPRITE_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h GUIMTDRV_TangoC32.h GUITDRV_ADS7846.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h KNOB.h KNOB_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group EMWIN/STemWin/Lib
    EMWIN/STemWin/Lib/: STemWin526_CM4_OS_IAR.a
  group EMWIN/STemWin/OS
    EMWIN/STemWin/OS/: GUI_X_OS.c
  group EMWIN/XBF_FONT
    EMWIN/XBF_FONT/: emwin_spi_font.c emwin_spi_font.h xbffontcreate.h
  group FATFS
    FATFS/option/: cc936.c
    FATFS/: diskio.c diskio.h exfuns.c ff.c ff.h ffconf.h
  group hardware
    EMWIN/XBF_FONT/: key.c
    drive/: led.c
  group library
    library/: misc.c stm32f4xx_adc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group LWIP/API
    LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP/APP
    LWIP/lwip_app/lwip_comm/: lwip_comm.c lwipopts.h
  group LWIP/ARCH
    LWIP/arch/: cc.h sys_arch.c
  group LWIP/CORE
    LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c lwip_init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP/IP
    LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP/NETIF
    LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group startup
    startup/: startup_stm32f40_41xxx.s
  group UCOS-III/uC-CPU
    UCOS-III/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
    UCOS-III/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group UCOS-III/uC-LIB
    UCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    UCOS-III/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group UCOS-III/UCOS-III/Ports
    UCOS-III/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOS-III/UCOS-III/Source
    UCOS-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group UCOS-III/UCOS_BSP
    UCOS-III/UCOS_BSP/: bsp.c bsp.h
  group UCOS-III/uCOS_CONFIG
    UCOS-III/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group USB/APP
    USB/USB_APP/: usb_bsp.c usb_conf.h usbh_conf.h usbh_usr.c usbh_usr.h
  group USB/DEVICE/class/hid
    USB/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
  group USB/DEVICE/class/msc
    USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB/DEVICE/core
    USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB/HOST/class/hid
    USB/STM32_USB_HOST_Library/Class/HID/src/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c
  group USB/HOST/core
    USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB/OTG
    USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c usb_otg.c
  group user
    user/: CharacterConvert.c CharacterConvert.h delay.c enc28j60.c ili9325.c init.c main.c malloc.c sdio_sdcard.c spi1.c spi2.c stm32f4xx_it.c sys.c w25qxx.c
    EMWIN/XBF_FONT/: OSTmr.c usart.c
